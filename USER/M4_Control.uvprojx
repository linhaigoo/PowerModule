# Keil uVision project M4_Control.uvprojx, settings and files
target M4_Control (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: UCOS-1-2 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F40XX,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP,__FPU_PRESENT
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\inc;..\USER;..\TASK;..\HARDWARE\Led;..\HARDWARE\Encoder;..\HARDWARE\GPIO;..\HARDWARE\OLED;..\HARDWARE\IIC;..\UCOS3\uCOS-III\Ports;..\UCOS3\uCOS-III\Source;..\UCOS3\uC-LIB;..\UCOS3\uC-CPU;.\CONFIG;.\APP;..\HARDWARE\DAC;..\HARDWARE\ADC;.\LIB\comLib;.\APP\screenCom
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c System_Init.c
  group HARDWARE
    ../HARDWARE/Led/: Led.c
    ../HARDWARE/Encoder/: Encoder.c
    ../HARDWARE/OLED/: oled.c snprintfModify.c
    ../HARDWARE/IIC/: IIC.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DAC/: dac.c
    ./LIB/comLib/: screenComBsp.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_wwdg.c
  group TASK
    ../TASK/: TASK_LED.c TASK_UART.c TASK_DISPLAY.c TASK_REGULATE.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group uC/CPU
    ../UCOS3/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../UCOS3/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../UCOS3/uC-LIB/Ports/: lib_mem_a.asm
  group uC/OS3_Source
    ../UCOS3/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS3_Port
    ../UCOS3/uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group USER/CONFIG
    ./CONFIG/: cpu_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group USER/APP
    ./APP/: InteractKeyScreen.c PowerModule.c screenComponent.c
    ./APP/screenCom/: screenComController.c
  group COM_LIB
    ./LIB/comLib/: comLib.c comLibApp.c screenCom.c
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1
